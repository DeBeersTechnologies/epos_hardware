Commit message: local changes

File: epos_hardware/launch/example.urdf (robot description, URDF)
Before this commit: robot example, 2 links, 1 joints
Links:
- added link link3, mass 1
Joints:
- added joint test_joint_2: type revolute, parent link2, child link3
